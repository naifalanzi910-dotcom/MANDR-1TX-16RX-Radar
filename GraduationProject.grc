options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: V
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e6
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5551
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5552
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_0_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5560
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_1
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5553
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_1_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5561
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_2
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5554
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_2_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5562
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_3
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_3_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5563
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_4
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_4_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5564
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_5
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_5_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5565
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_6
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5558
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_6_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5566
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_pull_source_0_7
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5559
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6001
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6002
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6006
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_0_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6014
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_0_1
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6010
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_1
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6003
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_1_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6007
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_1_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6015
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_1_1
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6011
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_2
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6004
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_2_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6008
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_2_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6016
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_2_1
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6012
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_3
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6005
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_3_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6013
    timeout: '1'
    type: complex
    vlen: V
  states: {}
- name: zeromq_push_sink_0_4
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:6009
    timeout: '1'
    type: complex
    vlen: V
  states: {}

connections:
- [zeromq_pull_source_0, '0', zeromq_push_sink_0, '0']
- [zeromq_pull_source_0_0, '0', zeromq_push_sink_0_0, '0']
- [zeromq_pull_source_0_0_0, '0', zeromq_push_sink_0_0_1, '0']
- [zeromq_pull_source_0_1, '0', zeromq_push_sink_0_1, '0']
- [zeromq_pull_source_0_1_0, '0', zeromq_push_sink_0_1_1, '0']
- [zeromq_pull_source_0_2, '0', zeromq_push_sink_0_2, '0']
- [zeromq_pull_source_0_2_0, '0', zeromq_push_sink_0_2_1, '0']
- [zeromq_pull_source_0_3, '0', zeromq_push_sink_0_3, '0']
- [zeromq_pull_source_0_3_0, '0', zeromq_push_sink_0_3_0, '0']
- [zeromq_pull_source_0_4, '0', zeromq_push_sink_0_0_0, '0']
- [zeromq_pull_source_0_4_0, '0', zeromq_push_sink_0_0_0_0, '0']
- [zeromq_pull_source_0_5, '0', zeromq_push_sink_0_1_0, '0']
- [zeromq_pull_source_0_5_0, '0', zeromq_push_sink_0_1_0_0, '0']
- [zeromq_pull_source_0_6, '0', zeromq_push_sink_0_2_0, '0']
- [zeromq_pull_source_0_6_0, '0', zeromq_push_sink_0_2_0_0, '0']
- [zeromq_pull_source_0_7, '0', zeromq_push_sink_0_4, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
